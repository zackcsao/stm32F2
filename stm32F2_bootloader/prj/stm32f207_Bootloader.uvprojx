# Keil uVision project stm32f207_Bootloader.uvprojx, settings and files
target stm32f207_Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207ZCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f207_Bootloader +hex
  c flags: Optim=4 OneElfS=1 uGnu=1 wLevel=2
  c define: STM32F207xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ..\src\application\app\inc;..\src\platform\driver\inc;..\src\platform\bsp\inc;..\src\platform\MCU\inc;..\src\platform\middleware\inc;..\src\platform\stdPeripheral\CMSIS\Include;..\src\platform\stdPeripheral\CMSIS\Device\ST\STM32F2xx\Include;..\src\platform\stdPeripheral\STM32F2xx_HAL_Driver\Inc;..\src\platform\stdPeripheral\STM32F2xx_HAL_Driver\Inc\Legacy;..\src\platform\middleware\FatFs\FATFS\App;..\src\platform\middleware\FatFs\FATFS\Target;..\src\platform\middleware\FatFs\inc;..\src\platform\middleware\LwIP\src\include\lwip\apps;..\src\platform\middleware\LwIP\src\include\lwip;..\src\platform\middleware\LwIP\src\include\lwip\priv;..\src\platform\middleware\LwIP\src\include\lwip\prot;..\src\platform\middleware\LwIP\src\include\netif;..\src\platform\middleware\LwIP\src\include\posix;..\src\platform\middleware\LwIP\src\include\posix\sys;..\src\platform\middleware\LwIP\system\arch;..\src\platform\middleware\LwIP\src\include;..\src\platform\middleware\STM32_USB_Host_Library\Core\Inc;..\src\platform\middleware\STM32_USB_Host_Library\Class\MSC\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group application
    ../src/application/app/src/: app_init.c task_test.c main.c task_deal_update_fatfs.c
  group bsp
    ../src/platform/bsp/src/: bsp.c usbh_conf.c usbh_diskio.c file_operations.c explorer.c
  group middleware
    ../src/platform/middleware/src/: common_tools.c fifo.c
  group MCU
    ../src/platform/MCU/src/: system_clock.c gpio.c i2c.c iwdg.c spi.c timer.c uart.c sdio.c flash.c
  group driver
    ../src/platform/driver/src/: drv_8025t.c drv_x5043.c
  group stdPeripheral
    ../src/platform/stdPeripheral/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_exti.c stm32f2xx_ll_gpio.c stm32f2xx_ll_pwr.c stm32f2xx_ll_rcc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_spi.c stm32f2xx_ll_tim.c stm32f2xx_ll_usart.c stm32f2xx_ll_usb.c stm32f2xx_ll_utils.c
    ../src/platform/stdPeripheral/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ../src/platform/stdPeripheral/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f207xx.s
  group FatFS
    ../src/platform/middleware/FatFs/FATFS/Target/: bsp_driver_sd.c sd_diskio.c
    ../src/platform/middleware/FatFs/FATFS/App/: fatfs.c
    ../src/platform/middleware/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../src/platform/middleware/FatFs/src/option/: syscall.c
  group stdPeripheral/HAL
    ../src/platform/stdPeripheral/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_flash.c stm32f2xx_hal.c stm32f2xx_hal_eth.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c stm32f2xx_hal_sd.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_pcd.c stm32f2xx_hal_hcd.c stm32f2xx_hal_flash_ex.c
  group USB/CORE
    ../src/platform/middleware/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_ctlreq.c usbh_core.c usbh_conf_template.c usbh_pipes.c
  group USB/MSC
    ../src/platform/middleware/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
