# Keil uVision project stm32f207.uvprojx, settings and files
target stm32f207 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207ZCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f207 +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ..\src\application\app\inc;..\src\platform\driver\inc;..\src\platform\bsp\inc;..\src\platform\MCU\inc;..\src\platform\middleware\inc;..\src\platform\stdPeripheral\CMSIS\Include;..\src\platform\stdPeripheral\CMSIS\Device\ST\STM32F2xx\Include;..\src\platform\stdPeripheral\STM32F2xx_HAL_Driver\Inc;..\src\platform\stdPeripheral\STM32F2xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group application
    ../src/application/app/src/: app_init.c task_test.c lwip.c ethernetif.c tcp_echoserver.c main.c
  group bsp
    ../src/platform/bsp/src/: bsp.c
  group middleware
    ../src/platform/middleware/src/: common_tools.c fifo.c
  group MCU
    ../src/platform/MCU/src/: system_clock.c adc.c gpio.c i2c.c iwdg.c spi.c timer.c uart.c
  group driver
    ../src/platform/driver/src/: drv_8025t.c
  group stdPeripheral
    ../src/platform/stdPeripheral/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_adc.c stm32f2xx_ll_exti.c stm32f2xx_ll_gpio.c stm32f2xx_ll_pwr.c stm32f2xx_ll_rcc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_spi.c stm32f2xx_ll_tim.c stm32f2xx_ll_usart.c stm32f2xx_ll_usb.c stm32f2xx_ll_utils.c
    ../src/platform/stdPeripheral/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ../src/platform/stdPeripheral/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f207xx.s
  group LwIP
    ../src/platform/middleware/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c ppp.c multilink.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../src/platform/middleware/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../src/platform/middleware/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../src/platform/middleware/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../src/platform/middleware/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../src/platform/middleware/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group stdPeripheral/HAL
    ../src/platform/stdPeripheral/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_eth.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c
